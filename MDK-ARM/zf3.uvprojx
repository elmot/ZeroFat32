# Keil uVision project zf3.uvprojx, settings and files
target zf3 Configuration (ARM-ADS)
  device: STM32F072CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: zf3 Configuration +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ..\Inc;      ..\Drivers\STM32F0xx_HAL_Driver\Inc;      ..\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;      ..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0;      ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;      ..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;      ..\Middlewares\Third_Party\FatFs\src;      ..\Middlewares\Third_Party\FreeRTOS\Source\include;      ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;      ..\Drivers\CMSIS\Include;      ..\Drivers\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_cortex.c stm32f0xx_hal_tim.c stm32f0xx_hal_i2c.c stm32f0xx_hal_pcd.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc_ex.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Application/User
    ../Src/: user_diskio.c stm32f0xx_it.c stm32f0xx_hal_msp.c usb_device.c usbd_conf.c main.c usbd_storage_if.c fatfs.c usbd_desc.c oled.c
